options:
  parameters:
    author: QRadioLink Contributors
    category: '[Examples]'
    comment: NBFM (Narrow Band FM) modulation and demodulation example
    copyright: Copyright 2024 QRadioLink Contributors
    description: This example demonstrates NBFM modulation and demodulation using gr-qradiolink blocks.
    generate_options: qt_gui
    id: nbfm_example
    output_language: python
    title: NBFM Example
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    comment: Audio sample rate (typically 8000 Hz for voice)
    value: '8000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate for the flowgraph
    value: '250000'
  states: {}
- name: audio_source
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Audio tone source (can be replaced with audio input)
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: Null sink for filtered output
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: nbfm_demod
  id: qradiolink_demod_nbfm
  parameters:
    carrier_freq: '1700'
    comment: NBFM Demodulator
    filter_width: '8000'
    samp_rate: samp_rate
    sps: '125'
  states: {}
- name: nbfm_mod
  id: qradiolink_mod_nbfm
  parameters:
    carrier_freq: '1700'
    comment: NBFM Modulator
    filter_width: '8000'
    samp_rate: samp_rate
    sps: '125'
  states: {}
- name: qtgui_freq_sink_c_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Frequency display of modulated signal
    fc: '0'
    fftsize: '1024'
    name: '"Modulated Signal"'
    type: complex
    ymax: '0'
  states: {}
- name: qtgui_time_sink_f_0
  id: qtgui_time_sink_x
  parameters:
    comment: Audio output display
    label1: '"Demodulated Audio"'
    name: '"Audio Output"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: '"Amplitude"'
  states: {}

connections:
- [audio_source, '0', nbfm_mod, '0']
- [blocks_throttle2_0, '0', nbfm_demod, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_c_0, '0']
- [nbfm_demod, '0', blocks_null_sink_0, '0']
- [nbfm_demod, '1', qtgui_time_sink_f_0, '0']
- [nbfm_mod, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
