options:
  parameters:
    author: gr-packet-protocols
    category: Packet Protocols
    comment: AX.25 KISS TNC Example
    description: Receive and verify signed text messages using NFM and AX.25
    generate_options: qt_gui
    id: confirmed_command
    output_language: python
    title: Signed Message Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/verified_message.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/signed_message_tx.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '127.0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      try:
          from gnuradio import nacl
          NACL_AVAILABLE = True
      except ImportError:
          NACL_AVAILABLE = False

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name='Message Verifier', in_sig=[np.uint8, np.uint8], out_sig=[np.uint8])
              self._msg_buffer = bytearray()
              self._key_buffer = bytearray()
          def work(self, input_items, output_items):
              msg_in = input_items[0]
              key_in = input_items[1]
              if len(msg_in) > 0:
                  self._msg_buffer.extend(msg_in.tolist())
              if len(key_in) > 0:
                  self._key_buffer.extend(key_in.tolist())
                  if len(self._key_buffer) > 32:
                      self._key_buffer = self._key_buffer[-32:]
              # Verify when we have message + signature (separated by 0x00)
              if len(self._msg_buffer) > 100 and len(self._key_buffer) >= 32:
                  try:
                      sep_idx = self._msg_buffer.find(0)
                      if sep_idx > 0 and len(self._msg_buffer) >= sep_idx + 65:
                          msg_bytes = bytes(self._msg_buffer[:sep_idx])
                          sig_bytes = bytes(self._msg_buffer[sep_idx+1:sep_idx+65])
                          key = bytes(self._key_buffer[:32])
                          if NACL_AVAILABLE and len(sig_bytes) == 64:
                              is_valid = nacl.verify_ed25519(msg_bytes, sig_bytes, key)
                              if is_valid:
                                  n = min(len(output_items[0]), len(msg_bytes))
                                  if n > 0:
                                      output_items[0][:n] = np.frombuffer(msg_bytes[:n], dtype=np.uint8)
                                      self._msg_buffer = self._msg_buffer[sep_idx+65:]
                                      return n
                          self._msg_buffer = self._msg_buffer[sep_idx+65:]
                  except:
                      pass
              return 0
  states: {}
- name: linux_crypto_kernel_keyring_source_0
  id: linux_crypto_kernel_keyring_source
  parameters:
    auto_repeat: 'False'
    key_id: '0'
  states: {}
- name: qradiolink_demod_nbfm_0
  id: qradiolink_demod_nbfm
  parameters:
    carrier_freq: '1700'
    filter_width: '8000'
    samp_rate: samp_rate
    sps: '125'
  states: {}

connections:
- [blocks_file_source_0, '0', qradiolink_demod_nbfm_0, '0']
- [blocks_float_to_char_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_file_sink_0, '0']
- [linux_crypto_kernel_keyring_source_0, '0', epy_block_0, '1']
- [qradiolink_demod_nbfm_0, '1', blocks_float_to_char_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
