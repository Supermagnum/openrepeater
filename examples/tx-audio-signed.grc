options:
  parameters:
    author: gr-packet-protocols
    category: Packet Protocols
    comment: Audio File with Signed AX.25 Frames
    description: Transmit audio file with signed signature and ASCII message frames in AX.25 at 2400 baud
    generate_options: qt_gui
    id: tx_audio_signed
    output_language: python
    run: 'False'
    title: Audio File with Signed Frames
  states: {}

blocks:
- name: audio_file_path
  id: variable_qtgui_entry
  parameters:
    label: Audio File Path
    type: string
    value: ''
  states: {}
- name: dest_callsign
  id: variable_qtgui_entry
  parameters:
    label: Dest Callsign
    type: string
    value: N0CALL
  states: {}
- name: message_text
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,2,1
    label: Message Text
    type: string
    value: ''
  states: {}
- name: output_audio_file
  id: variable_qtgui_entry
  parameters:
    label: Output Audio File Path
    type: string
    value: ''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: src_callsign
  id: variable_qtgui_entry
  parameters:
    label: Src Callsign
    type: string
    value: N0CALL
  states: {}
- name: use_pkcs11
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Use PKCS#11 (unchecked = Kernel Keyring)
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: start_button
  id: variable_qtgui_push_button
  parameters:
    comment: Start processing the audio file
    label: Start Processing
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: stop_button
  id: variable_qtgui_push_button
  parameters:
    comment: Stop processing
    label: Stop
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Combine audio and data frames (data muted during audio)
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: 1.0/127.0
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: Upsample data from 2400 to 48000 samples/sec
    interp: '20'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: 2400 baud rate limiter
    samples_per_second: '2400'
    type: byte
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    comment: Output Audio File (WAV format)
    file: /home/haaken/Musikk/cq+ax25.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Audio File Input (WAV format)
    file: /home/haaken/Musikk/cq.wav
    repeat: 'False'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import os

      try:
          from pkcs11 import lib as pkcs11_lib
          from pkcs11 import Token
          from pkcs11.constants import UserType, ObjectClass, KeyType, Mechanism
          PKCS11_AVAILABLE = True
      except ImportError:
          PKCS11_AVAILABLE = False

      try:
          from gnuradio import nacl
          NACL_AVAILABLE = True
      except ImportError:
          NACL_AVAILABLE = False

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Burst Trigger Audio + Signed Frames',
                  in_sig=[np.float32, np.uint8],
                  out_sig=[np.float32, np.uint8]
              )
              self._key_buffer = bytearray()
              self._pkcs11_lib = None
              self._use_pkcs11 = True
              self._audio_eof_detected = False
              self._data_frames_bytes = None
              self._data_output_idx = 0
              self._silence_count = 0
              self._silence_threshold = 48000  # 1 second of silence
              self._total_audio_samples = 0
              self._min_audio_samples = 96000  # Require at least 2 seconds of audio
              
              if PKCS11_AVAILABLE:
                  self._init_pkcs11()
          
          def _init_pkcs11(self):
              lib_paths = [
                  '/usr/lib/x86_64-linux-gnu/opensc-pkcs11.so',
                  '/usr/lib/opensc-pkcs11.so',
                  '/usr/lib/x86_64-linux-gnu/p11-kit-proxy.so',
                  '/usr/lib/p11-kit-proxy.so',
              ]
              for path in lib_paths:
                  if os.path.exists(path):
                      try:
                          self._pkcs11_lib = pkcs11_lib(path)
                          print(f"PKCS#11: Loaded {path}")
                          return True
                      except Exception as e:
                          continue
              return False
          
          def _get_token(self, pin=None):
              if not self._pkcs11_lib:
                  return None
              try:
                  tokens = self._pkcs11_lib.get_tokens()
                  if not tokens:
                      return None
                  token = tokens[0]
                  if pin:
                      token.open(UserType.USER, pin.encode())
                  else:
                      try:
                          token.open(UserType.USER)
                      except:
                          return None
                  return token
              except:
                  return None
          
          def _sign_with_pkcs11(self, data, pin=None):
              if not PKCS11_AVAILABLE or not self._pkcs11_lib:
                  return None
              try:
                  token = self._get_token(pin)
                  if not token:
                      return None
                  session = token.open(UserType.USER, pin.encode() if pin else None)
                  private_keys = session.get_objects({ObjectClass.PRIVATE_KEY, KeyType.EC})
                  if not private_keys:
                      return None
                  signature = private_keys[0].sign(data, mechanism=Mechanism.ECDSA)
                  return signature
              except Exception as e:
                  print(f"PKCS#11 signing error: {e}")
                  return None
          
          def _generate_frames_bytes(self):
              try:
                  import __main__
                  if hasattr(__main__, 'message_text'):
                      msg = getattr(__main__, 'message_text').value()
                      if msg:
                          msg_bytes = msg.encode('utf-8')
                          signature = None
                          
                          if self._use_pkcs11:
                              signature = self._sign_with_pkcs11(msg_bytes)
                          
                          if not signature and len(self._key_buffer) >= 32 and NACL_AVAILABLE:
                              key = bytes(self._key_buffer[:32])
                              signature = nacl.sign_ed25519(msg_bytes, key)
                          
                          frames = bytearray()
                          
                          if signature:
                              frames.extend(b'SIG')
                              frames.extend(signature)
                          
                          frames.extend(msg_bytes)
                          
                          return bytes(frames)
              except Exception as e:
                  print(f"Frame generation error: {e}")
                  pass
              return None
          
          def work(self, input_items, output_items):
              try:
                  import __main__
                  if hasattr(__main__, 'use_pkcs11'):
                      self._use_pkcs11 = getattr(__main__, 'use_pkcs11').value()
              except:
                  pass
              
              audio_in = input_items[0]
              key_in = input_items[1]
              audio_out = output_items[0]
              data_out = output_items[1]
              n = len(audio_in)
              
              if len(key_in) > 0 and not self._use_pkcs11:
                  self._key_buffer.extend(key_in.tolist())
                  if len(self._key_buffer) > 32:
                      self._key_buffer = self._key_buffer[-32:]
              
              if not self._audio_eof_detected:
                  # Always pass through audio while receiving it
                  self._total_audio_samples += n
                  audio_energy = np.sum(np.abs(audio_in))
                  
                  # Detect file end: all zeros after processing significant audio
                  # This handles files with silence at start and end
                  if n > 0:
                      if audio_energy < 1e-10 and self._total_audio_samples > 96000:
                          # After 2 seconds of audio, check for file end (all zeros)
                          self._silence_count += n
                          if self._silence_count >= 96000:  # 2 seconds of complete silence
                              self._audio_eof_detected = True
                              frames_bytes = self._generate_frames_bytes()
                              if frames_bytes:
                                  self._data_frames_bytes = bytearray(frames_bytes)
                                  self._data_output_idx = 0
                              print(f"File end detected after {self._total_audio_samples} samples")
                      else:
                          # Reset silence counter if we see any audio
                          if audio_energy > 1e-6:
                              self._silence_count = 0
                  else:
                      # n == 0 means file source stopped
                      if self._total_audio_samples > 0:
                          self._audio_eof_detected = True
                          frames_bytes = self._generate_frames_bytes()
                          if frames_bytes:
                              self._data_frames_bytes = bytearray(frames_bytes)
                              self._data_output_idx = 0
                          print(f"File source ended after {self._total_audio_samples} samples")
              
              if not self._audio_eof_detected:
                  audio_out[:n] = audio_in[:n]
                  data_out[:n] = 0
                  return n
              else:
                  audio_out[:n] = 0.0
                  if self._data_frames_bytes is not None and self._data_output_idx < len(self._data_frames_bytes):
                      remaining = len(self._data_frames_bytes) - self._data_output_idx
                      n_output = min(n, remaining)
                      if n_output > 0:
                          data_out[:n_output] = np.frombuffer(
                              self._data_frames_bytes[self._data_output_idx:self._data_output_idx+n_output],
                              dtype=np.uint8
                          )
                          self._data_output_idx += n_output
                          return n_output
                  data_out[:n] = 0
                  return n
  states: {}
- name: linux_crypto_kernel_keyring_source_0
  id: linux_crypto_kernel_keyring_source
  parameters:
    auto_repeat: 'False'
    key_id: '0'
  states: {}
- name: packet_protocols_ax25_encoder_0
  id: packet_protocols_ax25_encoder
  parameters:
    command_response: 'False'
    comment: AX.25 Encoder (2400 baud)
    dest_callsign: dest_callsign
    dest_ssid: '0'
    digipeaters: ''
    poll_final: 'False'
    src_callsign: src_callsign
    src_ssid: '0'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_char_to_float_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle2_0, '0', packet_protocols_ax25_encoder_0, '0']
- [blocks_wavfile_source_0, '0', epy_block_2, '0']
- [epy_block_2, '0', blocks_add_xx_0, '0']
- [epy_block_2, '1', blocks_throttle2_0, '0']
- [linux_crypto_kernel_keyring_source_0, '0', epy_block_2, '1']
- [packet_protocols_ax25_encoder_0, '0', blocks_char_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
