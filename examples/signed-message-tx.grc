options:
  parameters:
    author: gr-packet-protocols
    category: Packet Protocols
    comment: AX.25 KISS TNC Example
    description: Transmit signed text messages using NFM and AX.25
    generate_options: qt_gui
    id: signed_message_tx
    output_language: python
    title: Signed Message Transmitter
  states: {}

blocks:
- name: dest_callsign
  id: variable_qtgui_entry
  parameters:
    label: Dest Callsign
    type: string
    value: N0CALL
  states: {}
- name: message_text
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,2,1
    label: Message Text
    type: string
    value: ''
  states: {}
- name: nitrokey_slot
  id: variable_qtgui_entry
  parameters:
    label: Nitrokey Slot
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: send_button
  id: variable_qtgui_push_button
  parameters:
    label: Send
    pressed: '1'
    released: '0'
    type: int
    value: 'False'
  states: {}
- name: src_callsign
  id: variable_qtgui_entry
  parameters:
    label: Src Callsign
    type: string
    value: N0CALL
  states: {}
- name: use_pkcs11
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Use PKCS#11 (unchecked = Kernel Keyring)
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: default
    samp_rate: samp_rate
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: 1.0/127.0
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import os

      try:
          from pkcs11 import lib as pkcs11_lib
          from pkcs11 import Token
          from pkcs11.constants import UserType, ObjectClass, KeyType, Mechanism
          PKCS11_AVAILABLE = True
      except ImportError:
          PKCS11_AVAILABLE = False

      try:
          from gnuradio import nacl
          NACL_AVAILABLE = True
      except ImportError:
          NACL_AVAILABLE = False

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Message Signer (PKCS#11/Kernel Keyring)',
                  in_sig=[np.uint8],  # Key data from kernel keyring (fallback)
                  out_sig=[np.uint8]
              )
              self._key_buffer = bytearray()
              self._signed_msg = None
              self._output_idx = 0
              self._last_send = False
              self._pkcs11_lib = None
              self._use_pkcs11 = True  # Default to PKCS#11
              
              if PKCS11_AVAILABLE:
                  self._init_pkcs11()
          
          def _init_pkcs11(self):
              lib_paths = [
                  '/usr/lib/x86_64-linux-gnu/opensc-pkcs11.so',
                  '/usr/lib/opensc-pkcs11.so',
                  '/usr/lib/x86_64-linux-gnu/p11-kit-proxy.so',
                  '/usr/lib/p11-kit-proxy.so',
              ]
              for path in lib_paths:
                  if os.path.exists(path):
                      try:
                          self._pkcs11_lib = pkcs11_lib(path)
                          print(f"PKCS#11: Loaded {path}")
                          return True
                      except Exception as e:
                          continue
              return False
          
          def _get_token(self, pin=None):
              if not self._pkcs11_lib:
                  return None
              try:
                  tokens = self._pkcs11_lib.get_tokens()
                  if not tokens:
                      return None
                  token = tokens[0]
                  if pin:
                      token.open(UserType.USER, pin.encode())
                  else:
                      try:
                          token.open(UserType.USER)
                      except:
                          return None
                  return token
              except:
                  return None
          
          def _sign_with_pkcs11(self, data, pin=None):
              if not PKCS11_AVAILABLE or not self._pkcs11_lib:
                  return None
              try:
                  token = self._get_token(pin)
                  if not token:
                      return None
                  session = token.open(UserType.USER, pin.encode() if pin else None)
                  private_keys = session.get_objects({ObjectClass.PRIVATE_KEY, KeyType.EC})
                  if not private_keys:
                      return None
                  signature = private_keys[0].sign(data, mechanism=Mechanism.ECDSA)
                  return signature
              except Exception as e:
                  print(f"PKCS#11 signing error: {e}")
                  return None
          
          def work(self, input_items, output_items):
              # Check configuration
              try:
                  import __main__
                  if hasattr(__main__, 'use_pkcs11'):
                      self._use_pkcs11 = getattr(__main__, 'use_pkcs11').value()
              except:
                  pass
              
              # Collect key data from kernel keyring (if not using PKCS#11)
              key_in = input_items[0]
              if len(key_in) > 0 and not self._use_pkcs11:
                  self._key_buffer.extend(key_in.tolist())
                  if len(self._key_buffer) > 32:
                      self._key_buffer = self._key_buffer[-32:]
              
              try:
                  import __main__
                  if hasattr(__main__, 'send_button'):
                      btn = getattr(__main__, 'send_button')
                      if btn.value() and not self._last_send:
                          if hasattr(__main__, 'message_text'):
                              msg = getattr(__main__, 'message_text').value()
                              if msg:
                                  msg_bytes = msg.encode('utf-8')
                                  signature = None
                                  
                                  # Use PKCS#11 if configured
                                  if self._use_pkcs11:
                                      signature = self._sign_with_pkcs11(msg_bytes)
                                  
                                  # Fallback to kernel keyring + nacl
                                  if not signature and len(self._key_buffer) >= 32 and NACL_AVAILABLE:
                                      key = bytes(self._key_buffer[:32])
                                      signature = nacl.sign_ed25519(msg_bytes, key)
                                  
                                  if signature:
                                      self._signed_msg = msg_bytes + b'\x00' + signature
                                      self._output_idx = 0
                      
                      self._last_send = btn.value()
              except Exception as e:
                  pass
              
              if self._signed_msg and self._output_idx < len(self._signed_msg):
                  n = min(len(output_items[0]), len(self._signed_msg) - self._output_idx)
                  if n > 0:
                      output_items[0][:n] = np.frombuffer(
                          self._signed_msg[self._output_idx:self._output_idx+n],
                          dtype=np.uint8
                      )
                      self._output_idx += n
                      if self._output_idx >= len(self._signed_msg):
                          self._signed_msg = None
                          self._output_idx = 0
                      return n
              
              if len(output_items[0]) > 0:
                  output_items[0][:len(output_items[0])] = 0
                  return len(output_items[0])
              return 0
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, silence_threshold=1e-3, hold_samples=2400):
              gr.sync_block.__init__(
                  self,
                  name='Audio/Data Scheduler',
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32]
              )
              self._thresh = float(silence_threshold)
              self._hold = max(1, int(hold_samples))
              self._silence = self._hold

          def work(self, input_items, output_items):
              audio = input_items[0]
              data = input_items[1]
              out = output_items[0]
              n = min(len(out), len(audio), len(data))
              for i in range(n):
                  sample = audio[i]
                  if abs(sample) > self._thresh:
                      out[i] = sample
                      self._silence = 0
                      continue
                  if self._silence < self._hold:
                      out[i] = sample
                      self._silence += 1
                      continue
                  data_sample = data[i]
                  if abs(data_sample) > 1e-12:
                      out[i] = data_sample
                      continue
                  out[i] = 0.0
              return n
    hold_samples: '2400'
    silence_threshold: '0.001'
  states: {}
- name: linux_crypto_kernel_keyring_source_0
  id: linux_crypto_kernel_keyring_source
  parameters:
    auto_repeat: 'False'
    key_id: '0'
  states: {}
- name: packet_protocols_ax25_encoder_0
  id: packet_protocols_ax25_encoder
  parameters:
    command_response: 'False'
    comment: AX.25 Encoder
    dest_callsign: dest_callsign
    dest_ssid: '0'
    digipeaters: ''
    poll_final: 'False'
    src_callsign: src_callsign
    src_ssid: '0'
  states: {}
- name: qradiolink_mod_nbfm_0
  id: qradiolink_mod_nbfm
  parameters:
    carrier_freq: '1700'
    filter_width: '8000'
    samp_rate: samp_rate
    sps: '125'
  states: {}

connections:
- [audio_source_0, '0', epy_block_1, '0']
- [blocks_char_to_float_0, '0', epy_block_1, '1']
- [blocks_throttle2_0, '0', packet_protocols_ax25_encoder_0, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']
- [epy_block_1, '0', qradiolink_mod_nbfm_0, '0']
- [linux_crypto_kernel_keyring_source_0, '0', epy_block_0, '0']
- [packet_protocols_ax25_encoder_0, '0', blocks_char_to_float_0, '0']
- [qradiolink_mod_nbfm_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
